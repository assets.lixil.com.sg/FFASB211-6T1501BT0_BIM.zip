Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-12-01T10:58:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 01 10:58:06 2021 * Host: ws-115 * Database: C:\Users\JACK~1.YEL\AppData\Local\Temp\{182E317F-26A8-4BF6-BD7B-31D42386C99C}\ifc * Database version: 5507 * Database creation date: Wed Dec 01 10:58:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 01 10:58:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 01 10:58:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Codie Exposed Bath & Shower Mixer without Handspray, AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0):Codie Exposed Bath & Shower Mixer without Handspray:3573
In: Level 1
Classification: D2010700 (Uniformat); Material: Steel, Chrome Plated, Chrome
Pset_ManufacturerTypeInformation - ModelReference: Codie Exposed Bath & Shower Mixer without Handspray; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Codie Exposed Bath & Shower Mixer without Handspray
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0356298 m2; Volume: 0.000559337 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0): Codie Exposed Bath & Shower Mixer without Handspray; Family and Type: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0): Codie Exposed Bath & Shower Mixer without Handspray; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0): Codie Exposed Bath & Shower Mixer without Handspray; Type Id: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0): Codie Exposed Bath & Shower Mixer without Handspray; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: n/a; ProductGroup: n/a; ProductWeight: n/a; StyleSegment: n/a; SubCategory: n/a
Identity Data(Type) - Assembly Code: D2010700; Description: Codie Exposed Bath & Shower Mixer without Handspray; Keynote: N13; Manufacturer: American Standard; Model: Codie Exposed Bath & Shower Mixer without Handspray; OmniClass Number: 23.45.05.14.17; OmniClass Title: Showers; Type Comments: FFASB211-6T1501BT0; Type Name: Codie Exposed Bath & Shower Mixer without Handspray; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: bimstore; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/object-user-guide; BIMObjectName: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0); NBSDescription: Shower mixers; NBSNote: n/a; NBSObjectName: American Standard - Shower mixers; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/335
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_81; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-12-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffasb211-6t1501bt0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_BathAndShowerMixer_Codie_(FFASB211-6T1501BT0); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: FFASB211-6T1501BT0; ModelReference: Codie Exposed Bath & Shower Mixer without Handspray; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Codie Exposed Bath & Shower Mixer without Handspray; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
